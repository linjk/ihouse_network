# IAR project iHouse_network.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F4XX; xVECT_TAB_SRAM; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: includes\; hardware\; includes\STM32F4xx_StdPeriph_Driver\inc; peripherals\led
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: iHouse_network.bin
  ILINK.IlinkOutputFile: iHouse_network.out
  ILINK.IlinkIcfFile: E:\iHouse_Network\stm32f40x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group headware
    hardware/: bsp.c
  group includes
    includes/: core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h includes.h stm32f4xx.h stm32f4xx_conf.h system_stm32f4xx.h
  group includes/STM32F4xx_StdPeriph_Driver/src
    includes/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group peripherals/led
    peripherals/led/: led.c led.h
  group sources
    sources/: main.c system_stm32f4xx.c
  group startup
    startup/: startup_stm32f4xx.s
